# Keil uVision project 51_SPI_I2C_READ.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 51_SPI_I2C_READ +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Function\Beep;.\Function\I2C;.\Function\LCD12864;.\Function\main;.\Function\MLX90614;.\Function\RC522;.\Function\System
  group Source Group 1
    ./Function/Beep/: Beep.c
    ./Function/I2C/: I2C.C
    ./Function/LCD12864/: LCD12864.c
    ./Function/main/: main.c
    ./Function/MLX90614/: MLX90614.C
    ./Function/RC522/: RC522.c
    ./Function/System/: ASCII_HEX .c Delay.c Timer.c UART.c
